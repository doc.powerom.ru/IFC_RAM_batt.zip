Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Номер проекта
Time: 2022-09-15T02:05:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190225_1515(x64) - Exporter 19.2.10.7 - Альтернативный интерфейс 19.2.10.7
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 15 02:05:09 2022 * Host: Dell * Database: C:\Users\6EDA~1\AppData\Local\Temp\{E8D49051-FCFB-43A4-BC45-99E2B44F97F3}\ifc * Database version: 5507 * Database creation date: Thu Sep 15 02:04:41 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 15 02:04:42 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 15 02:04:42 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: П

# IfcSite, Default
RefLatitude: 55, 44, 57, 789001; RefLongitude: 37, 38, 4, 304809; RefElevation: 0 mm

# IfcBuilding, Наименование здания
LongName: Наименование здания
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
In: Наименование здания
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 1000 ВА (5)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 1000 ВА
Name
НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:1000 ВА:588560
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:1000 ВА:620571
НВО_КНС_ОнлайнИБПSmallTower_DKC:1000 ВА:626960
НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:1000 ВА:1017013
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:1000 ВА:1017824

# IfcBuildingElementProxy: 1000 ВА, без АКБ (3)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 1000 ВА, без АКБ
Name
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:1000 ВА, без АКБ:1017055
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:1000 ВА, без АКБ:1017115
НВО_КНС_ОнлайнИБПSmallTower_DKC:1000 ВА, без АКБ:1017310

# IfcBuildingElementProxy: 14 кВА 140 х 9 Ач, НВО_КНС_ОнлайнИБПСерияSoloMMB_DKC:14 кВА 140 х 9 Ач:657729
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 14 кВА 140 х 9 Ач

# IfcBuildingElementProxy: 14kVA/12,6kW Tower 2x20x7Ач, НВО_КНС_ОнлайнИБПСерияSoloMMB_DKC:14kVA/12,6kW Tower 2x20x7Ач:1017447
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 14kVA/12,6kW Tower 2x20x7Ач

# IfcBuildingElementProxy: 14kVA/12,6kW Tower 3x20x9Ач, НВО_КНС_ОнлайнИБПСерияSoloMMB_DKC:14kVA/12,6kW Tower 3x20x9Ач:1017465
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 14kVA/12,6kW Tower 3x20x9Ач

# IfcBuildingElementProxy: 14kVA/12,6kW Tower без АКБ, НВО_КНС_ОнлайнИБПСерияSoloMMB_DKC:14kVA/12,6kW Tower без АКБ:1017471
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 14kVA/12,6kW Tower без АКБ

# IfcBuildingElementProxy: 1500 ВА (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 1500 ВА
Name (НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:1500 ВА:...)
1016954
1017017

# IfcBuildingElementProxy: 2000 ВА (5)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2000 ВА
Name
НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:2000 ВА:1016970
НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:2000 ВА:1017021
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:2000 ВА:1017075
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:2000 ВА:1017154
НВО_КНС_ОнлайнИБПSmallTower_DKC:2000 ВА:1017332

# IfcBuildingElementProxy: 2000 ВА, без АКБ (3)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2000 ВА, без АКБ
Name
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:2000 ВА, без АКБ:1017082
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:2000 ВА, без АКБ:1017170
НВО_КНС_ОнлайнИБПSmallTower_DKC:2000 ВА, без АКБ:1017338

# IfcBuildingElementProxy: 3000 ВА (5)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 3000 ВА
Name
НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:3000 ВА:1016976
НВО_КНС_Линейно-интерактивныйИБПInfoRPro_DKC:3000 ВА:1017025
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:3000 ВА:1017089
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:3000 ВА:1017175
НВО_КНС_ОнлайнИБПSmallTower_DKC:3000 ВА:1017344

# IfcBuildingElementProxy: 3000 ВА, без АКБ (3)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 3000 ВА, без АКБ
Name
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:3000 ВА, без АКБ:1017096
НВО_КНС_ОнлайнИБПSmallRackmount_DKC:3000 ВА, без АКБ:1017180
НВО_КНС_ОнлайнИБПSmallTower_DKC:3000 ВА, без АКБ:1017350

# IfcBuildingElementProxy: AS400 (32)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: AS400
Name (Адаптер AS400:AS400:...)
620574
626962
702826
702842
750952
1017057
1017077
1017084
1017091
1017098
1017116
1017155
1017171
1017176
1017181
1017312
1017334
1017340
1017346
1017352
1017827
1017869
1017883
1093880
1093900
1093906
1093912
1093918
1093924
1093930
1093936
1093942

# IfcBuildingElementProxy: AS400INFO (8)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: AS400INFO
Name (Адаптер AS400INFO:AS400INFO:...)
604537
1016956
1016972
1016978
1017015
1017019
1017023
1017027

# IfcBuildingElementProxy: AS400MMD (90)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: AS400MMD
Name (Адаптер AS400:AS400MMD:...)
657731
690127
733297
741255
767089
1017401
1017425
1017429
1017449
1017467
1017473
1017942
1017958
1017964
1017970
1018002
1018039
1018059
1018079
1018099
1070670
1070673
1070695
1070698
1070704
1070707
1070713
1070716
1070722
1070725
1070731
1070734
1070740
1070743
1070749
1070752
1070758
1070761
1070767
1070770
1070776
1070779
1070785
1070788
1070794
1070797
1070803
1070806
1070812
1070815
1070821
1070824
1070830
1070833
1070839
1070842
1070848
1070851
1070857
1070860
1070866
1070869
1070875
1070878
1070884
1070887
1094127
1094144
1094149
1094154
1094159
1094164
1094169
1094174
1094179
1094184
1094189
1102980
1103002
1103009
1103016
1103023
1103030
1103037
1103044
1103051
1103058
1103065
1103072
1103079

# IfcBuildingElementProxy: BBC15P2A7 (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BBC15P2A7
Name (НВО_КНС_БатарейныйБлокSoloMD_DKC:BBC15P2A7:...)
767086
1017999

# IfcBuildingElementProxy: BBC15P2A9 (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BBC15P2A9
Name (НВО_КНС_БатарейныйБлокSoloMD_DKC:BBC15P2A9:...)
1017939
1018036

# IfcBuildingElementProxy: BBC20P2A7 (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BBC20P2A7
Name (НВО_КНС_БатарейныйБлокSoloMD_DKC:BBC20P2A7:...)
1017955
1018056

# IfcBuildingElementProxy: BBC20P2A9 (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BBC20P2A9
Name (НВО_КНС_БатарейныйБлокSoloMD_DKC:BBC20P2A9:...)
1017961
1018076

# IfcBuildingElementProxy: BBC40A9 (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BBC40A9
Name (НВО_КНС_БатарейныйБлокSoloMD_DKC:BBC40A9:...)
1017967
1018096

# IfcBuildingElementProxy: BPSMLR1-24V (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLR1-24V
Name (НВО_КНС_БатарейныйБлокBPSMLR_DKC:BPSMLR1-24V:...)
744584
1017647

# IfcBuildingElementProxy: BPSMLR1-36V (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLR1-36V
Name (НВО_КНС_БатарейныйБлокBPSMLR_DKC:BPSMLR1-36V:...)
1017590
1017734

# IfcBuildingElementProxy: BPSMLR2-48V (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLR2-48V
Name (НВО_КНС_БатарейныйБлокBPSMLR_DKC:BPSMLR2-48V:...)
1017604
1017757

# IfcBuildingElementProxy: BPSMLR2-72V (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLR2-72V
Name (НВО_КНС_БатарейныйБлокBPSMLR_DKC:BPSMLR2-72V:...)
1017607
1017772

# IfcBuildingElementProxy: BPSMLR3-96V (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLR3-96V
Name (НВО_КНС_БатарейныйБлокBPSMLR_DKC:BPSMLR3-96V:...)
1017610
1017787

# IfcBuildingElementProxy: BPSMLT1-36V, НВО_КНС_БатарейныйБлокBPSMLT_DKC:BPSMLT1-36V:750950
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLT1-36V

# IfcBuildingElementProxy: BPSMLT2-72V, НВО_КНС_БатарейныйБлокBPSMLT_DKC:BPSMLT2-72V:1017867
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLT2-72V

# IfcBuildingElementProxy: BPSMLT3-96V, НВО_КНС_БатарейныйБлокBPSMLT_DKC:BPSMLT3-96V:1017881
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPSMLT3-96V

# IfcBuildingElementProxy: BPT20P4A7, НВО_КНС_ШкафАКБTrioTT_DKC:BPT20P4A7:770296
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPT20P4A7

# IfcBuildingElementProxy: BPT20P4A9, НВО_КНС_ШкафАКБTrioTT_DKC:BPT20P4A9:1018125
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: BPT20P4A9

# IfcBuildingElementProxy: FONRMMD (4)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: FONRMMD
Name (Ролики серия Solo:FONRMMD:...)
657732
1017450
1017468
1017474

# IfcBuildingElementProxy: INFO1200S, НВО_КНС_ИБПInfo_DKC:INFO1200S:1093878
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFO1200S

# IfcBuildingElementProxy: INFO1500SI, НВО_КНС_ИБПInfoSI_DKC:INFO1500SI:1017909
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_СерыйМеталлик, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFO1500SI

# IfcBuildingElementProxy: INFO600S, НВО_КНС_ИБПInfo_DKC:INFO600S:702824
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFO600S

# IfcBuildingElementProxy: INFO800S, НВО_КНС_ИБПInfo_DKC:INFO800S:702840
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFO800S

# IfcBuildingElementProxy: INFO850SI, НВО_КНС_ИБПInfoSI_DKC:INFO850SI:757295
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_СерыйМеталлик, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFO850SI

# IfcBuildingElementProxy: INFOLCD1200I, НВО_КНС_ИБПInfo_DKC:INFOLCD1200I:1093910
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOLCD1200I

# IfcBuildingElementProxy: INFOLCD1500I, НВО_КНС_ИБПInfo_DKC:INFOLCD1500I:1093916
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOLCD1500I

# IfcBuildingElementProxy: INFOLCD1500S, НВО_КНС_ИБПInfo_DKC:INFOLCD1500S:1093922
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOLCD1500S

# IfcBuildingElementProxy: INFOLCD2000SI, НВО_КНС_ИБПInfo_DKC:INFOLCD2000SI:1093928
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOLCD2000SI

# IfcBuildingElementProxy: INFOLCD600I, НВО_КНС_ИБПInfo_DKC:INFOLCD600I:1093898
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOLCD600I

# IfcBuildingElementProxy: INFOLCD800I, НВО_КНС_ИБПInfo_DKC:INFOLCD800I:1093904
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOLCD800I

# IfcBuildingElementProxy: INFOPDU600, НВО_КНС_ИБПInfo_DKC:INFOPDU600:1093934
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOPDU600

# IfcBuildingElementProxy: INFOPDU800, НВО_КНС_ИБПInfo_DKC:INFOPDU800:1093940
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: INFOPDU800

# IfcBuildingElementProxy: MBSSMLR (40)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: MBSSMLR
Name (Внешний переключатель байпаса MBSSMLR:MBSSMLR:...)
604538
620575
626963
702827
702843
750953
1016957
1016973
1016979
1017016
1017020
1017024
1017028
1017058
1017078
1017085
1017092
1017099
1017117
1017156
1017172
1017177
1017182
1017313
1017335
1017341
1017347
1017353
1017828
1017870
1017884
1093881
1093901
1093907
1093913
1093919
1093925
1093931
1093937
1093943

# IfcBuildingElementProxy: RAILSMLR (38)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: RAILSMLR
Name (Рельсы для ИБП RAILSMLR:RAILSMLR:...)
690125
767087
778452
1017039
1017041
1017043
1017045
1017059
1017079
1017399
1017940
1017956
1017962
1017968
1029620
1070668
1070693
1070702
1070711
1070720
1070729
1070738
1070747
1070756
1070765
1070774
1070783
1070792
1070801
1070810
1070819
1070828
1070837
1070846
1070855
1070864
1070873
1070882

# IfcBuildingElementProxy: SMALLC2A10I (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: SMALLC2A10I
Name (НВО_КНС_ОнлайнИБПSmallConvert_DKC:SMALLC2A10I:...)
758958
1017924

# IfcBuildingElementProxy: SNMPMMD (90)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: SNMPMMD
Name (Адаптер SNMPSM2:SNMPMMD:...)
657730
690126
733298
741254
767088
1017400
1017424
1017428
1017448
1017466
1017472
1017941
1017957
1017963
1017969
1018001
1018038
1018058
1018078
1018098
1070669
1070672
1070694
1070697
1070703
1070706
1070712
1070715
1070721
1070724
1070730
1070733
1070739
1070742
1070748
1070751
1070757
1070760
1070766
1070769
1070775
1070778
1070784
1070787
1070793
1070796
1070802
1070805
1070811
1070814
1070820
1070823
1070829
1070832
1070838
1070841
1070847
1070850
1070856
1070859
1070865
1070868
1070874
1070877
1070883
1070886
1094128
1094145
1094150
1094155
1094160
1094165
1094170
1094175
1094180
1094185
1094190
1102979
1103001
1103008
1103015
1103022
1103029
1103036
1103043
1103050
1103057
1103064
1103071
1103078

# IfcBuildingElementProxy: SNMPSM (8)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: SNMPSM
Name (Адаптер SNMPSM:SNMPSM:...)
604536
1016955
1016971
1016977
1017014
1017018
1017022
1017026

# IfcBuildingElementProxy: SNMPSM2 (24)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: SNMPSM2
Name (Адаптер SNMPSM2:SNMPSM2:...)
620573
626961
702825
702841
750951
1017056
1017076
1017311
1017333
1017339
1017345
1017351
1017826
1017868
1017882
1093879
1093899
1093905
1093911
1093917
1093923
1093929
1093935
1093941

# IfcBuildingElementProxy: Solo MD 10000VA/9100W 20x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 10000VA/9100W 20x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 10000VA/9100W 20x7Ач:...)
1070863
1070867

# IfcBuildingElementProxy: Solo MD 10000VA/9100W 20x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 10000VA/9100W 20x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 10000VA/9100W 20x9Ач:...)
1070872
1070876

# IfcBuildingElementProxy: Solo MD 10000VA/9100W без АКБ (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 10000VA/9100W без АКБ
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 10000VA/9100W без АКБ:...)
1070881
1070885

# IfcBuildingElementProxy: Solo MD 12kVA/108kW 20x9Ач (4)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 12kVA/108kW 20x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 12kVA/108kW 20x9Ач:...)
690124
1017422
1070755
1070759

# IfcBuildingElementProxy: Solo MD 12kVA/108kW без АКБ (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 12kVA/108kW без АКБ
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 12kVA/108kW без АКБ:...)
1017398
1017426

# IfcBuildingElementProxy: Solo MD 4000VA/3600W 12x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 4000VA/3600W 12x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 4000VA/3600W 12x7Ач:...)
1070701
1070705

# IfcBuildingElementProxy: Solo MD 4000VA/3600W 15x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 4000VA/3600W 15x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 4000VA/3600W 15x7Ач:...)
1070710
1070714

# IfcBuildingElementProxy: Solo MD 4000VA/3600W 15x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 4000VA/3600W 15x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 4000VA/3600W 15x9Ач:...)
1070719
1070723

# IfcBuildingElementProxy: Solo MD 4000VA/3600W 2x15x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 4000VA/3600W 2x15x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 4000VA/3600W 2x15x7Ач:...)
1070667
1070671

# IfcBuildingElementProxy: Solo MD 4000VA/3600W 2x15x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 4000VA/3600W 2x15x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 4000VA/3600W 2x15x9Ач:...)
1070692
1070696

# IfcBuildingElementProxy: Solo MD 4000VA/3600W без АКБ (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 4000VA/3600W без АКБ
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 4000VA/3600W без АКБ:...)
1070728
1070732

# IfcBuildingElementProxy: Solo MD 5000VA/4500W 15x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 5000VA/4500W 15x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 5000VA/4500W 15x9Ач:...)
1070764
1070768

# IfcBuildingElementProxy: Solo MD 5000VA/4500W 2x15x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 5000VA/4500W 2x15x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 5000VA/4500W 2x15x7Ач:...)
1070737
1070741

# IfcBuildingElementProxy: Solo MD 5000VA/4500W 2x15x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 5000VA/4500W 2x15x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 5000VA/4500W 2x15x9Ач:...)
1070746
1070750

# IfcBuildingElementProxy: Solo MD 5000VA/4500W без АКБ (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 5000VA/4500W без АКБ
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 5000VA/4500W без АКБ:...)
1070773
1070777

# IfcBuildingElementProxy: Solo MD 6000VA/5400W 15x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 6000VA/5400W 15x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 6000VA/5400W 15x9Ач:...)
1070800
1070804

# IfcBuildingElementProxy: Solo MD 6000VA/5400W 2x15x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 6000VA/5400W 2x15x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 6000VA/5400W 2x15x7Ач:...)
1070782
1070786

# IfcBuildingElementProxy: Solo MD 6000VA/5400W 2x15x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 6000VA/5400W 2x15x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 6000VA/5400W 2x15x9Ач:...)
1070791
1070795

# IfcBuildingElementProxy: Solo MD 6000VA/5400W без АКБ (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 6000VA/5400W без АКБ
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 6000VA/5400W без АКБ:...)
1070809
1070813

# IfcBuildingElementProxy: Solo MD 7000VA/6300W 15x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 7000VA/6300W 15x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 7000VA/6300W 15x7Ач:...)
1070827
1070831

# IfcBuildingElementProxy: Solo MD 7000VA/6300W 20x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 7000VA/6300W 20x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 7000VA/6300W 20x7Ач:...)
1070836
1070840

# IfcBuildingElementProxy: Solo MD 7000VA/6300W 20x9Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 7000VA/6300W 20x9Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 7000VA/6300W 20x9Ач:...)
1070845
1070849

# IfcBuildingElementProxy: Solo MD 7000VA/6300W 2x15x7Ач (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 7000VA/6300W 2x15x7Ач
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 7000VA/6300W 2x15x7Ач:...)
1070818
1070822

# IfcBuildingElementProxy: Solo MD 7000VA/6300W без АКБ (2)
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Solo MD 7000VA/6300W без АКБ
Name (НВО_КНС_ОнлайнИБПСерияSoloMD_DKC:Solo MD 7000VA/6300W без АКБ:...)
1070854
1070858

# IfcBuildingElementProxy: TRIOTM10A10, НВО_КНС_ИБПTrioTM_DKC:TRIOTM10A10:709382
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM10A10

# IfcBuildingElementProxy: TRIOTM10A120, НВО_КНС_ИБПTrioTM_DKC:TRIOTM10A120:1094148
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM10A120

# IfcBuildingElementProxy: TRIOTM10A30, НВО_КНС_ИБПTrioTM_DKC:TRIOTM10A30:1094126
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM10A30

# IfcBuildingElementProxy: TRIOTM10A60, НВО_КНС_ИБПTrioTM_DKC:TRIOTM10A60:1094143
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM10A60

# IfcBuildingElementProxy: TRIOTM15A10, НВО_КНС_ИБПTrioTM_DKC:TRIOTM15A10:1094153
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM15A10

# IfcBuildingElementProxy: TRIOTM15A120, НВО_КНС_ИБПTrioTM_DKC:TRIOTM15A120:1094168
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM15A120

# IfcBuildingElementProxy: TRIOTM15A30, НВО_КНС_ИБПTrioTM_DKC:TRIOTM15A30:1094158
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM15A30

# IfcBuildingElementProxy: TRIOTM15A60, НВО_КНС_ИБПTrioTM_DKC:TRIOTM15A60:1094163
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM15A60

# IfcBuildingElementProxy: TRIOTM20A10, НВО_КНС_ИБПTrioTM_DKC:TRIOTM20A10:1094173
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM20A10

# IfcBuildingElementProxy: TRIOTM20A120, НВО_КНС_ИБПTrioTM_DKC:TRIOTM20A120:1094188
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM20A120

# IfcBuildingElementProxy: TRIOTM20A30, НВО_КНС_ИБПTrioTM_DKC:TRIOTM20A30:1094178
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM20A30

# IfcBuildingElementProxy: TRIOTM20A60, НВО_КНС_ИБПTrioTM_DKC:TRIOTM20A60:1094183
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTM20A60

# IfcBuildingElementProxy: TRIOTT10A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT10A0:1103007
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT10A0

# IfcBuildingElementProxy: TRIOTT10A10, НВО_КНС_ИБПTrioTT_DKC:TRIOTT10A10:1103014
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT10A10

# IfcBuildingElementProxy: TRIOTT10A30, НВО_КНС_ИБПTrioTT_DKC:TRIOTT10A30:1103021
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT10A30

# IfcBuildingElementProxy: TRIOTT12A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT12A0:1103028
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT12A0

# IfcBuildingElementProxy: TRIOTT12A15, НВО_КНС_ИБПTrioTT_DKC:TRIOTT12A15:1103035
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT12A15

# IfcBuildingElementProxy: TRIOTT15A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT15A0:1103042
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT15A0

# IfcBuildingElementProxy: TRIOTT15A10, НВО_КНС_ИБПTrioTT_DKC:TRIOTT15A10:1103049
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT15A10

# IfcBuildingElementProxy: TRIOTT20A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT20A0:1103056
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT20A0

# IfcBuildingElementProxy: TRIOTT20A10, НВО_КНС_ИБПTrioTT_DKC:TRIOTT20A10:1103063
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT20A10

# IfcBuildingElementProxy: TRIOTT30A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT30A0:1103070
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT30A0

# IfcBuildingElementProxy: TRIOTT40A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT40A0:1103077
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT40A0

# IfcBuildingElementProxy: TRIOTT8A0, НВО_КНС_ИБПTrioTT_DKC:TRIOTT8A0:741253
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT8A0

# IfcBuildingElementProxy: TRIOTT8A10, НВО_КНС_ИБПTrioTT_DKC:TRIOTT8A10:1102978
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT8A10

# IfcBuildingElementProxy: TRIOTT8A30, НВО_КНС_ИБПTrioTT_DKC:TRIOTT8A30:1103000
In: Этаж 01
Type - Material: DKC_Белый, DKC_Красный, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: TRIOTT8A30

# IfcBuildingElementProxy: Лого, Лого:Лого:770898
In: Этаж 01
Type - Material: DKC_КрасныйЛого
Pset_BuildingElementProxyCommon - Reference: Лого

# IfcBuildingElementProxy: Текст модели:150 мм Arial (14)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 150 мм Arial

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial

# IfcBuildingElementProxy: Текст модели:80 мм Arial (112)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 80 мм Arial
